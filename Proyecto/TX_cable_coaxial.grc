options:
  parameters:
    author: joan
    category: '[Modulos_joan]'
    generate_options: qt_gui
    id: TX_cable_coaxial
    output_language: python
    title: TX_cable_coaxial
  states: {}

blocks:
- name: Amp
  id: variable_qtgui_range
  parameters:
    label: A_Noise
    start: '0'
    step: '0.02'
    stop: '1'
    value: '0'
  states: {}
- name: Bit_rate
  id: variable
  parameters:
    value: Rs*bpsim
  states: {}
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad)
  states: {}
- name: Rs
  id: variable
  parameters:
    value: (32000*4)-8
  states: {}
- name: bpsim
  id: variable
  parameters:
    value: math.log(M,2)
  states: {}
- name: escala
  id: variable_qtgui_range
  parameters:
    label: escala
    start: '1'
    step: '1'
    stop: '256'
    value: '128'
  states: {}
- name: h
  id: variable
  parameters:
    value: '[1]*sps'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sps*Rs
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: tabla_de_verdad
  id: variable
  parameters:
    value: (0.77+0.77j,-0.77+0.77j,-0.77-0.77j,0.77-0.77j)
  states: {}
- name: variable_constellation_1
  id: variable_constellation
  parameters:
    const_points: (0.77+0.77j,-0.77+0.77j,-0.77-0.77j,0.77-0.77j)
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '4'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: an_noise
  id: analog_noise_source_x
  parameters:
    amp: Amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: escala
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Escritorio/2201606/labachata_manuelturizo.wav
    repeat: 'True'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tabla_de_verdad
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: h
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_2
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 1e9
    center_freq0: 1e9
    gain0: '100'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: p1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: p0
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: p2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: p1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: p0
  states: {state: disabled}

connections:
- [an_noise, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_float_to_char_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_char_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_2, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', virtual_sink_1_1, '0']
- [interp_fir_filter_xxx_0, '0', blocks_add_xx_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_1, '0', qtgui_const_sink_x_2, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
