options:
  parameters:
    author: joan
    category: '[Modulos_joan]'
    generate_options: qt_gui
    id: RX_cable_coaxial
    output_language: python
    title: RX_cable_coaxial
  states: {}

blocks:
- name: Rs
  id: variable
  parameters:
    value: 32000*4
  states: {}
- name: escala
  id: variable_qtgui_range
  parameters:
    label: escala
    start: '1'
    step: '1'
    stop: '256'
    value: '128'
  states: {}
- name: function_probe_1
  id: variable_function_probe
  parameters:
    block_id: prob1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (sps*Rs)-8
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: variable_constellation_1
  id: variable_constellation
  parameters:
    const_points: (0.77+0.77j,-0.77+0.77j,-0.77-0.77j,0.77-0.77j)
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '4'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: volumen
  id: variable_qtgui_range
  parameters:
    label: volumen
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: E3TRadio_diezmador_cc_0
  id: E3TRadio_diezmador_cc
  parameters:
    paso: '8'
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/sps
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/escala
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volumen
    type: float
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 2.1e9
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 2.1e9
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 1e9
    center_freq0: 100E6
    gain0: '50'
    samp_rate: samp_rate
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: received
  states: {}

connections:
- [E3TRadio_diezmador_cc_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', E3TRadio_diezmador_cc_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', digital_constellation_decoder_cb_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_0_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_3, '1']
- [blocks_multiply_const_vxx_1_0, '0', audio_sink_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_probe_signal_x_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_vector_sink_x_0, '0']
- [digital_constellation_decoder_cb_1, '0', blocks_unpacked_to_packed_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
