options:
  parameters:
    author: Diana_Ariza_Joan_Torres_Cristian_Rugeles
    generate_options: qt_gui
    id: Practica2
    output_language: python
    title: Bloques python
  states: {}

blocks:
- name: fc
  id: variable_qtgui_range
  parameters:
    label: 'Frecuencia '
    start: 88e6
    step: 0.1e6
    stop: 107e6
    value: 88e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6.25e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1, 2, -1)
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      class blk ( gr . sync_block ) :
      	def __init__ ( self ) : # only default arguments here
      		gr . sync_block . __init__ (
      			self ,
      			name = "Promedios_de_tiempos"  , # will show up in GRC
      			in_sig =[ np . float32 ] ,
      			out_sig =[ np . float32 , np . float32 , np . float32 , np . float32 , np . float32 ]
      			)
      		self . acum_anterior = 0
      		self . Ntotales = 0
      		self . acum_anterior1 = 0
      		self . acum_anterior2 = 0
      	def work ( self , input_items , output_items ) :
      		x = input_items [0] # Senial de entrada .
      		y0 = output_items [0] # Promedio de la senial
      		y1 = output_items [1] # Media de la senial
      		y2 = output_items [2] # RMS de la senial
      		y3 = output_items [3] # Potencia promedio de la senial
      		y4 = output_items [4] # Desv iac ion estandar de la senial
      		# Calculo del promedio
      		N = len ( x )
      		self . Ntotales = self . Ntotales + N
      		acumulado = self . acum_anterior + np . cumsum ( x )
      		self . acum_anterior = acumulado [N -1]
      		y0 [:]= acumulado / self . Ntotales
      		
      		# Calculo de la media cua drat ica
      		#x2=np.x.*np.x
      		x2 = np . multiply (x , x )
      		acumulado1 = self . acum_anterior1 + np . cumsum ( x2 )
      		self . acum_anterior1 = acumulado1 [N -1]
      		y1 [:] = acumulado1 / self . Ntotales
      		
      		# Calculo de la RMS
      		y2 [:] = np . sqrt ( y1 )
      		# Calculo de la potencia promedio
      		y3 [:] = np . multiply ( y2 , y2 )
      		# Calculo de la des viac ion estandar
      		x3 = np . multiply (x - y0 ,x - y0 )
      		acumulado2 = self . acum_anterior2 + np . cumsum ( x3 )
      		self . acum_anterior2 = acumulado2 [N -1]
      		y4 [:] = np . sqrt ( acumulado2 / self . Ntotales )
      		return len ( x )
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '25'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e4
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 400e3
    fc: fc
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Media cuadrática
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: RMS
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Potencia promedio
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Media
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_4
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Desviacion estandar
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: '15'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: '0'
    otw: sc16
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0, '0', epy_block_1, '0']
- [analog_noise_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', epy_block_1, '0']
- [blocks_complex_to_mag_0, '0', epy_block_1, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', epy_block_1, '0']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_1, '0', qtgui_number_sink_3, '0']
- [epy_block_1, '1', qtgui_number_sink_0, '0']
- [epy_block_1, '2', qtgui_number_sink_1, '0']
- [epy_block_1, '3', qtgui_number_sink_2, '0']
- [epy_block_1, '4', qtgui_number_sink_4, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
